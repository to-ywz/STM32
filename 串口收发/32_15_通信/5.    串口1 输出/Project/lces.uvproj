# Keil uVision project lces.uvproj, settings and files
target Project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: lces +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Library;..\User\delay;..\User\key;..\User\led;..\User\uart
  group System
    ./: STARTUP.A51
  group User
    ../User/: main.c
    ../User/key/: key.c
    ../User/delay/: delay.c
    ../User/led/: led.c
    ../User/uart/: uart.c
